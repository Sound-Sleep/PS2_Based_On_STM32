# Keil uVision project model.uvprojx, settings and files
target Model (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: model +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\LIBRARIES\FWLIB\inc;..\LIBRARIES\CMSIS;..\LIBRARIES\SYSTEM\delay;..\LIBRARIES\SYSTEM\sys;..\USER;..\LIBRARIES\HARDWARE\ps2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group SYSTEM
    ../LIBRARIES/SYSTEM/delay/: delay.c
    ../LIBRARIES/SYSTEM/sys/: sys.c
  group STARTUP
    ../LIBRARIES/CMSIS/STARTUP/: startup_stm32f10x_hd.s
  group CMSIS
    ../LIBRARIES/CMSIS/: system_stm32f10x.c core_cm3.c stm32f10x.h
  group HARDWARE
    ../LIBRARIES/HARDWARE/ps2/: pstwo.c
  group FWLIB
    ../LIBRARIES/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
